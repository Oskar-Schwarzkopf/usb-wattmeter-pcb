# IAR project USBPowerMetre.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: App; Bsp; STM8S_StdPeriph_Driver\inc; STM8S_StdPeriph_Driver\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: USBPowerMetre.hex
  ILINK.IlinkOutputFile: USBPowerMetre.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group App
    App/: delay.c disp.c sys_init.c
  group Bsp
    Bsp/: adcx.c key.c oled.c runled.c
  group STM8S_StdPeriph_Driver/src
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_gpio.c stm8s_tim1.c
